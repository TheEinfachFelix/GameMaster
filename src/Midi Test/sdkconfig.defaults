## src/Midi Test/sdkconfig.defaults
```kconfig
CONFIG_TINYUSB_MIDI_COUNT=1
#CONFIG_TINYUSB_CDC_ENABLED=y
# CONFIG_TINYUSB_DESC_CUSTOM_PID=0x4001
```
